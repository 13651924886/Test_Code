# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Mylib;..\User;..\Mylib;D:\MDK\ARM\Packs\ARM\CMSIS\5.5.1\CMSIS\Include;..\Mylib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Mylib
    ../Mylib/: led.c delay.c key.c oled.c ad.c can1.c usart1.c usart3.c usart6.c tick.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c startup_stm32f4xx.s system_stm32f4xx.c stm32f4xx_spi.c
